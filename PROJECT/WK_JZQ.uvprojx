# Keil uVision project WK_JZQ.uvprojx, settings and files
target WK_JZQ_V2_3 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WK_JZQ_V2_3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,JZQ_V2_3
  c include: ..\CORE;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LIGHT;..\HARDWARE\RELAY;..\HARDWARE\RF;..\HARDWARE\SD_CARD;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\HARDWARE\W5500;..\MY_TASK;..\SOFTWARE\BAIDU_IOT;..\SOFTWARE\CRC8_16;..\SOFTWARE\DATA_MAP;..\SOFTWARE\DATA_TYPE;..\SOFTWARE\DHCP;..\SOFTWARE\DNS;..\SOFTWARE\ENTERNET;..\SOFTWARE\FILE;..\SOFTWARE\JSON;..\SOFTWARE\mqttsrc;..\SOFTWARE\PING;..\SOFTWARE\POWER;..\SOFTWARE\WK_JSON;..\STM32F10x_FWLib\inc;..\SYSTEM\CONFIG;..\SYSTEM\CPU_PORT;..\SYSTEM\DELAY;..\SYSTEM\MALLOC;..\SYSTEM\MY_OS;..\SYSTEM\SYS;..\SYSTEM\MY_FUN;..\SOFTWARE\CMD;..\SOFTWARE\DEBUG;..\..\WK_JZQ_V2.6;..\SYSTEM\RTC;..\SOFTWARE\NTP;..\SYSTEM\IWDG;..\HARDWARE;..\USER;..\SOFTWARE\CScript;..\SOFTWARE\SWD;..\HARDWARE\UART
  memory RVCT4: ROM 0x8002800 size 0x38000
  memory RVCT9: RAM 0x20000004 size 0x27fc
  group USER
    ../USER/: main.c fun_list.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32_LIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/CPU_PORT/: os_cpu_c.c os_cpu_a.asm
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/MY_OS/: os_fats.c os_mem.c os_msg.c os_sys.c os_task.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/MY_FUN/: my_fun.c
    ../SYSTEM/RTC/: rtc.c
    ../SYSTEM/IWDG/: iwdg.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/LIGHT/: light.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/RF/: rf.c
    ../HARDWARE/SD_CARD/: fats.c MMC_SD.C spi.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/W25QXX/: flash.c
    ../HARDWARE/W5500/: W5500.c
    ../HARDWARE/: HARD_IRQ.c
    ../HARDWARE/UART/: uart.c
  group SOFTWARE
    ../SOFTWARE/BAIDU_IOT/: baidu_iot.c
    ../SOFTWARE/CRC8_16/: crc8_16.c
    ../SOFTWARE/DATA_MAP/: data_map.c
    ../SOFTWARE/DATA_TYPE/: data_type.c
    ../SOFTWARE/DHCP/: dhcp.c
    ../SOFTWARE/DNS/: dns.c
    ../SOFTWARE/ENTERNET/: enternet.c
    ../SOFTWARE/FILE/: file.c
    ../SOFTWARE/JSON/: cJSON.c
    ../SOFTWARE/PING/: ping.c
    ../SOFTWARE/POWER/: power.c
    ../SOFTWARE/WK_JSON/: wk_json.c
    ../SOFTWARE/CMD/: cmd.c
    ../SOFTWARE/DEBUG/: debug.c
    ../SOFTWARE/NTP/: ntp.c
    ../SOFTWARE/CScript/: cScript.c
    ../SOFTWARE/SWD/: swd.c
  group MY_TASK
    ../MY_TASK/: my_topmsg.c my_lcd.c my_rf.c my_autocontrol.c my_light.c my_cfg.c my_idle.c my_iot.c my_light_new.c my_messeg.c my_w5500.c my_debug.c
  group MQTT
    ../SOFTWARE/mqttsrc/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group README
    ../: ReadMe.txt
target WK_JZQ_V2_5 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: WK_JZQ_V2_5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,JZQ_V2_5
  c include: as above
  memory RVCT4: ROM 0x8002800 size 0x38000
  memory RVCT9: RAM 0x20000004 size 0x27fc
  link misc: --callgraph
target WK_JZQ_V2_6 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: WK_JZQ_V2_6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,JZQ_V2_6
  c include: as above
  memory RVCT4: ROM 0x8002800 size 0x38000
  memory RVCT9: RAM 0x20000004 size 0x27fc
